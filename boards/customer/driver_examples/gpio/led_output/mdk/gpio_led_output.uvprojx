# Keil uVision project gpio_led_output.uvprojx, settings and files
target gpio_led_output Debug (ARM-ADS)
  device: MKL33Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF800,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_led_output.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL33Z64VLK4, FRDM_KL43Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/MKL43Z4/drivers;..;../../../../../../devices/MKL43Z4/utilities;../../../..;../../../../../../devices/MKL43Z4
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  scatter file: MKL33Z64xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MKL33Z644/: system_MKL33Z644.c MKL33Z644.h
    ../../../../../../devices/MKL33Z644/arm/: startup_MKL33Z644.s
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MKL43Z4/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_gpio.h fsl_gpio.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group source
    ../: gpio_led_output.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../devices/MKL43Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
target gpio_led_output Release (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0plus")
  output: gpio_led_output.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL43Z256VLH4, FRDM_KL43Z, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL43Z256xxx4_flash.scf
  link misc: --remove
