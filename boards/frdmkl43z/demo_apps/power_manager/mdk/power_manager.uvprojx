# Keil uVision project power_manager.uvprojx, settings and files
target power_manager Debug (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0plus")
  output: power_manager.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL43Z256VLH4, FRDM_KL43Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MKL43Z4/drivers;..;../../../../../devices/MKL43Z4/utilities;../../..;../../../../../devices/MKL43Z4
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL43Z256xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKL43Z4/arm/: startup_MKL43Z4.s
    ../../../../../devices/MKL43Z4/: system_MKL43Z4.c system_MKL43Z4.h
  group doc
    ../: readme.txt
  group source
    ../: clock_mcglite.c power_manager.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../../devices/MKL43Z4/drivers/: fsl_uart.h fsl_uart.c fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MKL43Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group notifier
    ../../../../../devices/MKL43Z4/utilities/: fsl_notifier.c fsl_notifier.h
target power_manager Release (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0plus")
  output: power_manager.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL43Z256VLH4, FRDM_KL43Z, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL43Z256xxx4_flash.scf
  link misc: --remove
