# Keil uVision project flexio_spi_dma_spi_transfer_master.uvprojx, settings and files
target flexio_spi_dma_spi_transfer_master Debug (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0plus")
  output: flexio_spi_dma_spi_transfer_master.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL43Z256VLH4, TWR_KL43Z48M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../../../CMSIS/Include;../../../../../../../../devices;../../../../../../../../devices/MKL43Z4/drivers;../..;..;../../../../../../../../devices/MKL43Z4/utilities;../../../../../../../../middleware/dma_manager_2.0.0;../../../../../..;../../../../../../../../devices/MKL43Z4
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL43Z256xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../../../../devices/MKL43Z4/arm/: startup_MKL43Z4.s
    ../../../../../../../../devices/MKL43Z4/: system_MKL43Z4.c system_MKL43Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MKL43Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_uart.h fsl_uart.c fsl_dmamux.h fsl_dmamux.c fsl_dma.h fsl_dma.c fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_flexio.c fsl_flexio.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_dma.c fsl_flexio_spi_dma.h fsl_spi.h fsl_spi.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
  group source
    ../: flexio_spi_dma_spi_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../../devices/MKL43Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group dma_manager
    ../../../../../../../../middleware/dma_manager_2.0.0/: fsl_dma_manager.c fsl_dma_manager.h
target flexio_spi_dma_spi_transfer_master Release (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0plus")
  output: flexio_spi_dma_spi_transfer_master.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL43Z256VLH4, TWR_KL43Z48M, TOWER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL43Z256xxx4_flash.scf
  link misc: --remove
